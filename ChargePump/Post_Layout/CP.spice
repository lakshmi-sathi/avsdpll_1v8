* SPICE3 file created from CP.ext - technology: sky130A
.include sky130nm.lib
.option scale=0.01u

XM1000 a_n67_1018# Down VDD VDD sky130_fd_pr__pfet_01v8 w=72 l=15
+  ad=2304 pd=208 as=2341.69 ps=162.938
XM1001 VDD a_103_713# a_70_634# VDD sky130_fd_pr__pfet_01v8 w=540 l=15
+  ad=17562.7 pd=1222.03 as=9243.53 ps=623.743
XM1002 a_311_496# a_n67_652# a_261_1083# GND sky130_fd_pr__nfet_01v8 w=540 l=15
+  ad=17820 pd=1146 as=9503.42 ps=624.706
XM1003 a_n67_652# Up VDD VDD sky130_fd_pr__pfet_01v8 w=72 l=15
+  ad=2304 pd=208 as=2341.69 ps=162.938
XM1004 a_70_634# Down a_20_484# VDD sky130_fd_pr__pfet_01v8 w=540 l=15
+  ad=9243.53 pd=623.743 as=17820 ps=1146
XM1005 GND a_20_484# a_20_484# GND sky130_fd_pr__nfet_01v8 w=42 l=15
+  ad=1356.69 pd=96.0863 as=1386 ps=150
XM1006 a_261_1083# a_115_506# GND GND sky130_fd_pr__nfet_01v8 w=540 l=15
+  ad=9503.42 pd=624.706 as=17443.2 ps=1235.4
XM1007 a_n67_652# Up GND GND sky130_fd_pr__nfet_01v8 w=36 l=15
+  ad=1188 pd=138 as=1162.88 ps=82.3597
XM1008 Out a_n67_1018# a_70_634# VDD sky130_fd_pr__pfet_01v8 w=42 l=15
+  ad=1386 pd=150 as=718.941 ps=48.5134
XM1009 a_n67_1018# Down GND GND sky130_fd_pr__nfet_01v8 w=36 l=15
+  ad=1188 pd=138 as=1162.88 ps=82.3597
XM1010 GND a_115_506# a_115_506# GND sky130_fd_pr__nfet_01v8 w=41 l=15
+  ad=1324.39 pd=93.7986 as=1353 ps=148
XM1011 a_311_496# a_311_496# VDD VDD sky130_fd_pr__pfet_01v8 w=42 l=15
+  ad=1428 pd=152 as=1365.98 ps=95.0469
XM1012 a_261_1083# Up Out GND sky130_fd_pr__nfet_01v8 w=42 l=15
+  ad=739.155 pd=48.5882 as=1386 ps=150
XM1013 a_103_713# a_103_713# VDD VDD sky130_fd_pr__pfet_01v8 w=42 l=15
+  ad=1386 pd=150 as=1365.98 ps=95.0469
C0 VDD GND 3.88fF

*c1 Out 0 6f

v1 VDD GND 1.8
v2 Up 0 0
*PULSE 0 1.8 4ns 6p 6p 100n 200n
v3 Down 0 0

.ic v(Out) = 0
.control
tran 1n 20u
plot v(Up) v(Down) v(Out)+2
.endc
